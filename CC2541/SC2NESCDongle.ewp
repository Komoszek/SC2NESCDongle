# IAR project SC2NESCDongle.ewp, settings and files
configuration CC2541EM (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; CC2540_MINIDK; BLINK_LEDS; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_UART_DMA=2; HAL_DMA=TRUE; HAL_KEY=TRUE; HAL_UART=TRUE; HAL_LED=TRUE; HAL_LCD=FALSE; OSC32K_CRYSTAL_INSTALLED=FALSE; chip=2541
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Include; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile\CC254x; ..\..\Profiles\SimpleProfile; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\hal\target\CC2540EB
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    ../Source/: ioCC254x_bitdef.h OSAL_SC2NESCDongle.c SC2NESCDongle.c SC2NESCDongle.h SC2NESCDongle_Main.c scbt.h wiimote.h wm_crypto.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_cent.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi.h npi_spi.c npi_uart.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Roles/CC254x/: central.c central.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/GATT/: gattservapp_util.c
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
